Commit message: Test visualization for robot urdf

File: helmoro_base/helmoro_sim/helmoro_description/urdf/helmoro.urdf (robot description, URDF)
Before this commit: robot Helmoro, 1 links, 0 joints
Links:
- removed link base_footprint
